# IAR project CruiseControlFW.ewp, settings and files
configuration CruiseControlFW (ARM, debug)
  General.OGChipSelectEditMenu: STM32F412RG ST STM32F412RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F412Rx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Core/Inc/CruiseControl; ../Core/Inc/PowerOptimization; ../Core/Inc/SysLib; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CruiseControlFW.hex
  ILINK.IlinkOutputFile: CruiseControlFW.out
  ILINK.IlinkIcfFile: stm32f412rx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f412rx.s
  group Application/User/Core
    ../Core/Src/: main.c cli.c vehicle_data.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/CruiseControl
    ../Core/Src/CruiseControl/: cc_state.c cc_inputs.c cc_control.c cc_gradient.c
  group Application/User/PowerOptimization
    ../Core/Src/PowerOptimization/: po_optimizer.c
  group Application/User/SysLib
    ../Core/Src/SysLib/: sys_adc.c sys_can.c sys_cc_dac.c sys_crc.c sys_flash.c sys_gpio.c sys_imu.c sys_info_dac.c sys_soc.c sys_spi.c sys_time.c sys_uart.c sys_wdg.c sys_xmodem.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
